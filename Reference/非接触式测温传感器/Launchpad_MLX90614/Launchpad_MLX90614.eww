<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MLX90614_MSP430G2553.ewp</path>
  </project>
  <batchBuild/>
</workspace>


